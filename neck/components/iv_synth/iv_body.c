#include "iv_body.h"

/* Моды взяты по измерениям настоящих скрипок; частоты гуляют от инструмента к
 * инструменту на десятки герц, поэтому точность здесь не самоцель — важно, что
 * их несколько, что они узкие и что между ними есть провалы.
 *
 * A0  ~280 Гц — воздушный резонанс корпуса (Гельмгольца, через эфы);
 * B1- ~460 и B1+ ~530 Гц — главные моды дерева, они дают «грудь» звука;
 *     ~700 Гц — область, без которой середина проваливается;
 *    ~2500 Гц — мостовой холм, широкий и невысокий: он отвечает за яркость,
 *               и добротность у него нарочно низкая, иначе получается свисток.
 *
 * Фильтр верхних частот на 180 Гц — не косметика: корпус скрипки ниже своего
 * воздушного резонанса не излучает почти ничего, а волновод в этой области
 * копит постоянную составляющую, которой в звуке взяться неоткуда. */
static const struct {
    float f0, q, gain_db;
} MODES[] = {
    { 280.0f,  9.0f,  8.0f },
    { 460.0f, 13.0f,  9.0f },
    { 530.0f, 13.0f,  8.0f },
    { 700.0f,  5.0f,  4.0f },
    { 2500.0f, 1.0f,  6.0f },
};

void iv_body_init(iv_body_t *b, float sample_rate)
{
    iv_biquad_highpass(&b->f[0], sample_rate, 180.0f, 0.7f);
    for (int i = 0; i < IV_BODY_SECTIONS - 1; ++i) {
        iv_biquad_peak(&b->f[i + 1], sample_rate,
                       MODES[i].f0, MODES[i].q, MODES[i].gain_db);
    }
}

void iv_body_reset(iv_body_t *b)
{
    for (int i = 0; i < IV_BODY_SECTIONS; ++i) {
        iv_biquad_reset(&b->f[i]);
    }
}

void iv_body_render(iv_body_t *b, float *x, size_t n)
{
    float *restrict p = x;

    for (int i = 0; i < IV_BODY_SECTIONS; ++i) {
        iv_biquad_t *f = &b->f[i];
        const float b0 = f->b0, b1 = f->b1, b2 = f->b2, a1 = f->a1, a2 = f->a2;
        float z1 = f->z1, z2 = f->z2;

        for (size_t k = 0; k < n; ++k) {
            const float in = p[k];
            const float y = b0 * in + z1;
            z1 = b1 * in - a1 * y + z2;
            z2 = b2 * in - a2 * y;

            /* Гашение денормалов: у резонатора корпуса добротность высокая,
             * хвост длинный, и без этого он доживает до денормальных значений —
             * а они на ESP32 стоят десятков тактов на операцию. */
            if (z1 > -1e-20f && z1 < 1e-20f) {
                z1 = 0.0f;
            }
            p[k] = y;
        }

        f->z1 = z1;
        f->z2 = z2;
    }
}
