#include "iv_power.h"

/* Опорные точки кривой разряда. Взяты по типовой характеристике LiPo при
 * токе порядка 0.2C — это как раз режим обоих устройств.
 *
 * Верхняя точка 4.20 В — напряжение полного заряда, нижняя 3.30 В: ниже
 * защита банки отключает нагрузку, и показывать там что-то уже поздно. */
static const struct { uint16_t mv; uint8_t pct; } CURVE[] = {
    { 4200, 100 },
    { 4100,  90 },
    { 4000,  80 },
    { 3900,  65 },
    { 3800,  50 },
    { 3700,  35 },
    { 3600,  20 },
    { 3500,  10 },
    { 3400,   5 },
    { 3300,   1 },
};

/* Выше этого напряжения на батарее быть не может: значит, меряется не она —
 * например, устройство питается от USB, а делитель висит на общей шине. */
#define BATT_MAX_MV 4350

/* Ниже этого измерение означает «делителя нет» или «АЦП не поднялся»:
 * разряженная банка отключается защитой около 3.0 В, до нуля не доходит. */
#define BATT_MIN_MV 2500

uint8_t iv_batt_percent(uint16_t millivolts)
{
    if (millivolts < BATT_MIN_MV || millivolts > BATT_MAX_MV) {
        return IV_BATT_UNKNOWN;
    }

    const int n = (int)(sizeof(CURVE) / sizeof(CURVE[0]));
    if (millivolts >= CURVE[0].mv) {
        return CURVE[0].pct;
    }
    for (int i = 1; i < n; ++i) {
        if (millivolts >= CURVE[i].mv) {
            /* Линейно внутри отрезка. Считаем в целых: дробей тут не нужно,
             * а плавающая точка в этом месте только мешает. */
            const int dv = CURVE[i - 1].mv - CURVE[i].mv;
            const int dp = CURVE[i - 1].pct - CURVE[i].pct;
            return (uint8_t)(CURVE[i].pct + (millivolts - CURVE[i].mv) * dp / dv);
        }
    }
    /* Между защитой банки и нижней точкой кривой: заряда нет, но устройство
     * ещё живо — отдаём единицу, а не «неизвестно». */
    return 1;
}
