/* Базовая математика, общая для обеих прошивок и для хостовых тестов.
 * Здесь не должно быть ничего из ESP-IDF: этот код собирается и на компьютере.
 *
 * Всё, что зовётся на каждый сэмпл, определено прямо здесь как static inline, и
 * это не вкусовщина, а замер на плате. У Xtensa вызов функции — это оконный
 * `entry`/`retw`, а float по соглашению о вызовах едет в целочисленных
 * регистрах, то есть каждый аргумент и результат стоят пары `wfr`/`rfr`.
 * На сэмпл таких вызовов набиралось под сорок, и синтез съедал 68 % аудиоядра
 * при потолке 40. Всё, что зовётся раз в блок (расчёт коэффициентов, где и
 * так expf с atan2f), остаётся обычными функциями в iv_dsp.c. */
#ifndef IV_DSP_H
#define IV_DSP_H

#include <stddef.h>

#ifdef __cplusplus
extern "C" {
#endif

/* Утилиты. Стоят первыми: ими пользуются inline-функции ниже. */
static inline float iv_clampf(float v, float lo, float hi)
{
    return v < lo ? lo : (v > hi ? hi : v);
}

static inline float iv_lerpf(float a, float b, float t)
{
    return a + (b - a) * t;
}

/* Однополюсный сглаживатель параметров.
 *
 * Управляющие параметры приходят из другой задачи редкими скачками (200 Гц), а
 * читаются в аудиопотоке каждый сэмпл. Без сглаживания скачок частоты или
 * громкости даёт щелчок, поэтому через этот фильтр проходит каждый параметр,
 * который слышно. */
typedef struct {
    float y; /* текущее значение */
    float a; /* коэффициент полюса, 0..1 */
} iv_smooth_t;

/* tau_s — постоянная времени в секундах: время выхода на ~63 % от цели.
 *
 * Предел точности: в float32 фильтр не сходится к цели вплотную, а застревает
 * на расстоянии примерно ulp(target) / (2 * (1 - a)). Для цели 440 Гц при
 * tau = 5 мс и 48 кГц это ~3.7e-3 Гц, то есть 0.014 цента — неслышимо.
 * Для затухания к нулю предела нет: там ulp мал, а хвост добивается гашением
 * денормалов. Знать про это стоит, если фильтр когда-нибудь применят к
 * величине, где нужна точная сходимость к большому значению. */
void  iv_smooth_init(iv_smooth_t *s, float sample_rate, float tau_s, float initial);
void  iv_smooth_reset(iv_smooth_t *s, float value);

static inline float iv_smooth_process(iv_smooth_t *s, float target)
{
    s->y = target + s->a * (s->y - target);
    /* Гасим денормалы: на затухании к нулю они стоят десятков тактов на операцию
     * и способны сорвать бюджет аудиоблока. */
    if (s->y > -1e-20f && s->y < 1e-20f) {
        s->y = 0.0f;
    }
    return s->y;
}

/* Однополюсный ФНЧ для звука.
 *
 * Внутри это тот же самый фильтр, что и сглаживатель выше, — разница только в
 * том, чем задают полюс: сглаживателю удобнее постоянная времени, фильтру
 * тембра — частота среза. Связь между ними tau = 1/(2*pi*fc), и общий код
 * заодно означает общее гашение денормалов: на затухании к тишине они стоят
 * десятков тактов на операцию. */
typedef struct {
    iv_smooth_t s;
} iv_lpf_t;

void  iv_lpf_init(iv_lpf_t *f, float sample_rate, float cutoff_hz);
/* Пересчёт среза. Вызывается раз в блок, а не на каждый сэмпл: внутри expf. */
void  iv_lpf_set_cutoff(iv_lpf_t *f, float sample_rate, float cutoff_hz);
void  iv_lpf_reset(iv_lpf_t *f, float value);

static inline float iv_lpf_process(iv_lpf_t *f, float x)
{
    return iv_smooth_process(&f->s, x);
}

/* Фазовая задержка однополюсного фильтра y = (1-p)*x + p*y на частоте hz,
 * в сэмплах.
 *
 * Нужна для настройки волновода: период ноты складывается из длины линий
 * задержки И задержки всего, что стоит в петле. Если фильтр не учесть, струна
 * будет стабильно фальшивить — на A4 полюс 0.65 даёт почти два сэмпла, это
 * около тридцати центов. */
float iv_onepole_phase_delay(float pole, float hz, float sample_rate);

/* ---- Линия задержки с дробной задержкой ---------------------------------- */

/* Ёмкость буфера. Степень двойки: заворот индекса становится маской вместо
 * деления, а в аудиопотоке это на каждый сэмпл дважды на голос.
 * 512 сэмплов при 48 кГц — период 94 Гц; самая низкая струна скрипки G3 (196 Гц)
 * проходит с запасом вдвое даже с учётом того, что линия держит только часть
 * периода. */
#define IV_DELAY_MAX 512

typedef struct {
    float buf[IV_DELAY_MAX];
    int   w;     /* куда пишем следующий сэмпл */
    float delay; /* задержка в сэмплах, дробная */
    float last;  /* последний отданный сэмпл: волновод читает его до записи */
} iv_delay_t;

void iv_delay_init(iv_delay_t *d, float delay);
/* Обнуляет содержимое, задержку оставляет: так гасят струну. */
void iv_delay_clear(iv_delay_t *d);

/* Задержка меняется каждый сэмпл — это и есть глиссандо. Значение зажимается
 * в допустимый диапазон, вызывающему проверять не нужно. */
static inline void iv_delay_set(iv_delay_t *d, float delay)
{
    /* Снизу — единица: при меньшей задержке интерполяция читала бы сэмпл,
     * который ещё не записан. Сверху остаётся запас в два сэмпла на второй
     * отсчёт интерполяции и на заворот индекса. */
    d->delay = iv_clampf(delay, 1.0f, (float)(IV_DELAY_MAX - 2));
}

/* Кладёт x и возвращает сэмпл, положенный delay тактов назад.
 * Дробная часть берётся линейной интерполяцией. */
static inline float iv_delay_tick(iv_delay_t *d, float x)
{
    /* Точка чтения считается до записи, а читается после: при задержке около
     * нуля это один и тот же сэмпл, и порядок решает, вернём мы вход или
     * содержимое буфера годичной давности. */
    float rp = (float)d->w - d->delay;
    if (rp < 0.0f) {
        rp += (float)IV_DELAY_MAX;
    }

    d->buf[d->w] = x;
    d->w = (d->w + 1) & (IV_DELAY_MAX - 1);

    const int   i0 = (int)rp;
    const float f  = rp - (float)i0;
    const int   i1 = (i0 + 1) & (IV_DELAY_MAX - 1);

    d->last = d->buf[i0] + f * (d->buf[i1] - d->buf[i0]);
    return d->last;
}

/* ---- Биквад -------------------------------------------------------------- */

/* Прямая форма II транспонированная: два элемента состояния, устойчива к
 * накоплению ошибки во float лучше прямой формы I при плавающих коэффициентах. */
typedef struct {
    float b0, b1, b2, a1, a2;
    float z1, z2;
} iv_biquad_t;

void  iv_biquad_reset(iv_biquad_t *f);
/* Формулы RBJ. gain_db > 0 — подъём, < 0 — провал. */
void  iv_biquad_peak(iv_biquad_t *f, float sample_rate, float f0, float q, float gain_db);
void  iv_biquad_highpass(iv_biquad_t *f, float sample_rate, float f0, float q);

static inline float iv_biquad_process(iv_biquad_t *f, float x)
{
    const float y = f->b0 * x + f->z1;
    f->z1 = f->b1 * x - f->a1 * y + f->z2;
    f->z2 = f->b2 * x - f->a2 * y;

    /* Гашение денормалов: у резонатора корпуса добротность высокая, хвост
     * длинный, и без этого он доживает до денормальных значений — а они на
     * ESP32 стоят десятков тактов на операцию. */
    if (f->z1 > -1e-20f && f->z1 < 1e-20f) {
        f->z1 = 0.0f;
    }
    return y;
}

/* Номер MIDI-ноты в частоту; a4_hz — строй (обычно 440). */
float iv_note_to_hz(float midi_note, float a4_hz);

#ifdef __cplusplus
}
#endif
#endif /* IV_DSP_H */
